## tests/kernel/unit/stack/Kconfig
```kconfig
# Copyright (c) 2026 inovex GmbH
# SPDX-License-Identifier: Apache-2.0

rsource "../common/Kconfig"

source "Kconfig.zephyr"
```
